options:
  parameters:
    generate_options: qt_gui
    id: twotone
    output_language: python
  states: {}

blocks:
- name: ToneFreq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '50'
    step: '100'
    stop: '10000'
    value: '700'
  states: {}
- name: ToneFreq2
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '50'
    step: '100'
    stop: '10000'
    value: '1900'
  states: {}
- name: ToneLevel
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '.01'
    stop: '1'
    value: '0.23'
  states: {}
- name: ToneLevel2
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '.01'
    stop: '1'
    value: '0.23'
  states: {}
- name: balance
  id: variable_qtgui_range
  parameters:
    label: balance
    orient: Qt.Horizontal
    start: '-1'
    step: '.01'
    stop: '+1'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: ToneLevel
    freq: ToneFreq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: ToneLevel2
    freq: ToneFreq2
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: hw:RadioHatCodec,0
    num_inputs: '2'
    samp_rate: samp_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1 - balance/2
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1 + balance/2
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '3500'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '100'
    win: firdes.WIN_BLACKMAN
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', low_pass_filter_0, '0']
- [blocks_complex_to_float_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_complex_to_float_0, '1', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '1']
- [blocks_multiply_const_vxx_1, '0', qtgui_time_sink_x_0, '1']
- [low_pass_filter_0, '0', blocks_complex_to_float_0, '0']

metadata:
  file_format: 1
